## Class to build and install with gnatmake 


RDEPENDS:${PN}:append = "libada"
DEPENDS:append = " libada"
