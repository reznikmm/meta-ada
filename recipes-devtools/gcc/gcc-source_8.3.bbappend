FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = "file://0099-libada.patch file://0098-avoid-ln-s-in-ada.patch"

