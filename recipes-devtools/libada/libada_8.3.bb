require recipes-devtools/gcc/gcc-${PV}.inc
require libada.inc

