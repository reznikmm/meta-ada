require recipes-devtools/gcc/gcc-${PV}.inc
require gnattools-cross.inc

